# Keil uVision project uaboatprj.uvprojx, settings and files
target uaboatprj (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uaboatprj +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__TARGET_FPU_VFP=1
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\include;..\..\BaseDrive;..\..\BaseDrive\GPS;..\..\BaseDrive\control;..\..\BaseDrive\RS485;..\..\Math\inc;..\..\USMART;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c config.h stm32f4xx_it.c
  group BaseDrive
    ../../BaseDrive/: bsp_usart.c bsp_delay.c can1.c can2.c sys.c pwm.c dr16.c led.c usart.c bsp_stmflash.c T12_remote_controller.c ZL5SERVO.c PickPlane.c BMS.c hmcsensor.c
  group Lib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_spi.c
  group Cmsis
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../../Libraries/CMSIS/Include/: arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cm4_simd.h
software components: CMSIS:CORE 5.2.0
